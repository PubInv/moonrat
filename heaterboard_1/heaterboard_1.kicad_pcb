# Repository PubInv/moonrat

File README.md:

DOI: [10.5281/zenodo.17694076](https://zenodo.org/records/17694076) for Release V1.0.1

<h1 align="center">MoonRatII, A Tote-Size Portable Incubator for Rapid Field Work</h1>

Aliases used by other developers include [Moonrat](https://github.com/PubInv/moonrat/tree/main/legacy/moonrat), [Rice MiniCubator](https://github.com/PubInv/moonrat/tree/main/legacy/RiceMiniCubator), and [Rice Petri FI](https://github.com/PubInv/moonrat/tree/main/legacy/RicePetriFI). Visit the [Legacy](https://github.com/PubInv/moonrat/tree/main/legacy) folder for the work of volunteers prior to December 2022 and the hand built prototype.
**MoonratII** development effort began January 2023.   

# Status, March 01, 2026 
| Milestone               | Target Date   | Status       |  
|-------------------------|---------------|--------------|  
| Write and submit paper to *Hardware X*  | Feb 26, 2026  | 🟢 Completed  | 
| Project Closure  | Feb 28, 2026 | 🟢 Completed |

# Status, December 01, 2025  
| Milestone               | Target Date   | Status       |  
|-------------------------|---------------|--------------|  
| Write and submit paper to *Hardware X*  | Dec 04, 2025  | 🟢 Planned  | 
| Project Closure  | Dec 10, 2025 | 🟢 Planned |

# Status, November 17, 2025  
| Milestone               | Target Date   | Status       |  
|-------------------------|---------------|--------------|  
| New 3D printed controller enclosure top ordered from Xometry | Nov 18, 2025  | 🟢 Completed  | 
| Changes to controller enclosure top  | Nov 17, 2025  | 🟢 Completed  | 
| Write and submit paper to *Hardware X*  | Nov 25, 2025  | 🟢 Planned  | 

### Updated controller enclosure top design
- Realigned power port opening with enclosure bottom.
- Shifted and enlarged key cap holes for improved clearance.

# Status, November 02, 2025  
The project build is complete. 

| Milestone               | Target Date   | Status       |  
|-------------------------|---------------|--------------|  
| Write and submit paper to *Hardware X*  | Nov 20, 2025  | 🟢 Planned  | 
| Project Closure  | Nov 21, 2025 | 🟢 Planned |

# Status, August 2025  

The mechanical design phase for the MoonRat II enclosure is officially complete. All recent updates, including finalizing mounting holes, component spacing, and structural parameters, have been committed. The finalized design files are now being test printed. 
Pending a successful print, the enclosure will be ready for assembly.

**Latest Progress -> We’re finalizing all updated FreeCAD 3D models by next week!** This includes:  
- New enclosure design - improved insulation/portability 
- Redesigned controller mounts - 3D-printed, better cable management
- Mechanical optimizations - easier assembly/maintenance

### Next Steps  
| Milestone               | Target Date   | Status       |  
|-------------------------|---------------|--------------|  
| FreeCAD model completion | Aug 20, 2025  | 🟡 In progress |  
| MVP prototype build     | Aug 27, 2025 | 🟢 Planned    |  
| Write and submit paper to *Hardware X*  | Nov 15, 2025  | 🟢 Planned |  

---  
**Hardware X Paper Focus**:  
- Open-source medical hardware  
- Low-cost neonatal incubator design  
- Reproducibility documentation ([Journal guidelines](https://www.journals.elsevier.com/hardware-x))  

# Status, April 28, 2025  
Created a standalone schematic for heaterboard PCB.

# Status, January 2025  
#### Project presentation on YouTube (Click image to watch)

#### Updated Experiment.com succesful project funding round
In January 2023, 13 generous patrons funded the production of five complete MoonRatII prototypes. we updated them with the [project results](https://experiment.com/projects/tote-size-portable-incubator-for-rapid-field-work
).
#### 2024 field testing resulted in future unit changes:
- Heater board redesign with a Dallas One wire digital temperature thermometer and a 4.7 ohm pull up resistor.
- Design a universal heater board cage to secure the heater board beneath the container lid in any external enclosure.
- Adjust top button spacing in KiCad.
- Add bottom mounting holes to the enclosure.

# Status, November 2024 
A scientific research paper is tentatively scheduled for March 2025 in the HardwareX journal.

# Status, September 2024  
Prototypes of the MoonratII were field tested in two locations - the Galapagos Islands by researcher Auja Bywater and in Tanzania by Dr. Robert Read. The heater features the TMP36 low voltage temperature sensor. A HardwareX scientific research paper is slated for October 2024 publication.

# Status, April 2024  
The MoonRatII team has produced five Printed Circuit Assemblies (Control and Heater) of the Rev 1 PWB for use by the USA team and five Printed Circuit Assemblies (Control and Heater) of the Rev 2 PWB for use by  the Mexico team. Enclosure design for the Controller Assembly of Rev 3 PWB is underway TBA. 

# Status January 2024
[Dr. Robert Read](https://www.pubinv.org) and [Melanie Laporte](https://github.com/melanielaporte) presented the MoonRatII project. Watch the [presentation](https://www.youtube.com/watch?v=yTW_BcTsaGw&t=22s). 

# Current Design Summary
In one schematic and PCB, we have developed a "Control Assembly" and a "Heater Assembly".  
- The Control Assembly will be in an enclosure detachable from the incubation chamber.  
- The Heater Assembly will mounted internal to the incubation assembly under the unit top. Current to a heating pad or pads has changed from the previously used TMP36 low voltage temperature sensor to a digital temperature sensor. 
- A rechargable battery with its recharging station will complete a MoonRatII incubator system.
  
## Image Gallery - Current FreeCAD Assembly Designs
|A    |B    |C    |
| --- | --- | --- |
|  |  | |
|  |  |  |
|  |  |  |  

# 2023 MoonRatII Design

### Fundamental Modularity: The 6-wire appliance 
The connections from the controller to the heater needs only 6 wires:
1. GND (ground, nominally voltage 0).
2. +12V PWR (the heating elements requires approximately 12V power).
3. HEAT ON (Vin).
4. +5V (for the thermometer).
5. SIG - data from the digital "one-wire" format.
6. UNK - a final wire is included for future functionality that is unknown right now.  It is connected as a redundant ground in Rev 1 and Rev 2.

These (esp. the power) should probably be rated for 2 amps, but in practice 1 amp is probably good enough.

## Initial Design Approach Block Diagram
From the 2020 design.  
<a
href="https://user-images.githubusercontent.com/5296671/86680945-b470ad80-bfc4-11ea-9ef6-19c4f70aceba.png">  
Basic Structure of Portable Incubator (1)
</a> 

## Motivation
By building a small, portable, intelligent incubator that can maintain constant elevated temperature, a variety of biological experiments and assays can be
performed "in the field" without having access to a electric grid power.

## Origin
This is an offshoot of the [Rapid E. coli project](https://github.com/PubInv/rapid-e-coli). It is an attempt to build a better, smaller, more intelligent
portable incubator that the Armadillo, described [elsewhere](http://jhe.ewb.org.au/index.php/jhe/article/view/127) and buildable from an [instructable](https://www.instructables.com/id/Portable-Petrifilm-Incubator-for-Inexpensive-In-Fi/).

## References (Incomplete)
- Petrifilms [https://www.3m.com/3M/en_US/company-us/all-3m-products/~/ECOLICT-3M-Petrifilm-E-coli-Coliform-Count-Plates/?N=5002385+3293785155&rt=rud](https://www.3m.com/3M/en_US/company-us/all-3m-products/~/ECOLICT-3M-Petrifilm-E-coli-Coliform-Count-Plates/?N=5002385+3293785155&rt=rud)
- EPA Guidelines [https://19january2017snapshot.epa.gov/sites/production/files/2015-11/documents/drinking_water_sample_collection.pdf](https://19january2017snapshot.epa.gov/sites/production/files/2015-11/documents/drinking_water_sample_collection.pdf)
- Original Incubator Paper [http://jhe.ewb.org.au/index.php/jhe/article/view/127](http://jhe.ewb.org.au/index.php/jhe/article/view/127)
- Construction of a Low-cost Mobile Incubator for Field and Laboratory Use [https://www.jove.com/t/58443/construction-low-cost-mobile-incubator-for-field-laboratory](https://www.jove.com/t/58443/construction-low-cost-mobile-incubator-for-field-laboratory)
- Solar Powered Portable Culture Incubator [https://www.jscimedcentral.com/Pediatrics/pediatrics-3-1063.pdf](https://www.jscimedcentral.com/Pediatrics/pediatrics-3-1063.pdf)
- World Health Organization
- Fuzzy Logic - 

## Acknowledgements
Thanks to [Dr. Sabia Abidi](https://profiles.rice.edu/faculty/sabia-abidi) of Rice University for input and references.

## MoonratII Team
[Robert L. Read - Founder of Public Invention](https://github.com/PubInv/) 

[F. Lee Erickson](https://github.com/ForrestErickson)

[Melanie Laporte](https://github.com/MelanieLaporte)  

[Silvia Castillas](https://github.com/SilviaKarbid)  

[Harshit Kumar](https://github.com/harshit9602)

[Enrique Ruiz](https://github.com/kurama79) 

[Horacio Garcia](https://github.com/HJGV05) 

<hr>
<h6><i> Updated by Melanie Laporte, 20240512</i></h6>

## KiCad design heaterboard_1/heaterboard_1.kicad_pcb

Board: 2 copper layers, 25.2 x 65.0 mm, 15 parts (0 on the bottom side), 5 nets.

Parts:
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
H5, H6: MountingHole_Pad_3.5mm; MountingHole_3.5mm_Pad_Via
J7: Screw_Terminal_01x03; GeneralPurposeAlarmDevicePCB_282834-3_1x03_P2.54mm_Horizont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
J9: Screw_Terminal_01x06; GeneralPurposeAlarmDevicePCB_282834-6_1x02_p254mm_Horizontal
J10: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J11, J12: Screw_Terminal_01x02; GeneralPurposeAlarmDevicePCB_282834-2_1x02_P2.54mm_Horizont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
R7: 4K7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SM1: Logo_Open_Hardware_Small; OSHW-Logo2_7.3x6mm_SilkScreen
TP1: +5P; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP2: TP_GND; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP3: TempOut_IB; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP4: HeaterDrive_IB; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP5: VCCQ; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded

Connections:
+5P: C1.1, J7.3, J9.4, J10.3, J10.8, R7.2, TP1.1
/HeaterDrive_IB: J9.3, J10.1, J10.10, J11.2, J12.2, TP4.1
/TempOut_IB: J7.2, J9.5, J10.4, J10.7, R7.1, TP3.1
GND1: C1.2, H5.1, H6.1, J7.1, J9.1, J9.6, J10.2, J10.9, TP2.1
VCCQ: J9.2, J10.5, J10.6, J11.1, J12.1, TP5.1

## KiCad design moonratII/pcb_Heater/Heater_board_Rev2/Heater_board_Rev2.kicad_pcb

Board: 2 copper layers, 108.0 x 65.0 mm, 11 parts (0 on the bottom side), 5 nets.

Parts:
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: Schottky 2A; D_SMB
H5, H6: MountingHole_Pad_3.5mm; MountingHole_3.5mm_Pad_Via
J9: Screw_Terminal_01x06; 1x6P 20A -40℃~+105℃ 300V Green 12~30 Straight pin 5.08mm 2.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
J10: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J11: Screw_Terminal_01x02; TerminalBlock_TE_282834-2_1x02_P2.54mm_Horizontal
R7: 1R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP2: TP_GND; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U1: DS18B20; TO-92_Inline
U1#2: TMP36GRTZ-REEL7; SOT-23-5

Connections:
+5P: C1.1, J9.4, J10.3, J10.8, R7.2, U1#2.2 (+Vs)
GND1: C1.2, H5.1, H6.1, J9.1, J9.6, J10.2, J10.9, TP2.1, U1.1 (GND), U1#2.5 (V_{SS})
HeaterDrive_IB: D1.1 (K), J9.3, J10.1, J10.10, J11.2
TempOut_IB: J9.5, J10.4, J10.7, R7.1, U1.2 (DQ), U1.3 (V_{DD}), U1#2.1 (Vout)
VCCQ: J9.2, J10.5, J10.6, J11.1

## KiCad design moonratII/pcb_moonratII/moonratII.kicad_pcb

Board: 2 copper layers, 108.0 x 65.0 mm, 35 parts (1 on the bottom side), 25 nets.

Parts:
A1: Arduino_UNO_R3; Arduino_UNO_R3_NoMountingHoles3D_Text_Top_&_Bottom
BZ1: Buzzer_D12mm_H9.6mm_LS7.6mm; Buzzer_12.2mm_9.7mm_7.62mm
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: Schottky 2A; D_SMB
F1: Polyfuse 6A; Fuse_BSMD_1812
H1, H2, H3, H4, H5, H6: MountingHole_Pad_3.5mm; MountingHole_3.5mm_Pad_Via
J1: Barrel_Jack_Switch_SMT; BarrelJack_CLIFF_FC681465S_SMT_Horizontal
J2: HS96L03W2C03_0.96_Oled; OLED_HS96L03W2C03_0.96_WithNuts
J5, J10: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J6, J9: Screw_Terminal_01x06; 1x6P 20A -40℃~+105℃ 300V Green 12~30 Straight pin 5.08mm 2.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
J11: Screw_Terminal_01x02; TerminalBlock_TE_282834-2_1x02_P2.54mm_Horizontal
Q1: IRF540N; TO-220-3_Horizontal_TabDown
Q2: BSS138; SOT-23
R1, R7: 1R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: DNI; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R6, R9: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2, SW3: 6mm 2 Pin Tact NO Breadboard Friendly; Switch_Tactile_THT_6x6mm
TP1, TP2: TP_GND; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U1: TMP36GRTZ-REEL7; SOT-23-5

Connections:
+5P: C1.1, J9.4, J10.3, J10.8, R7.2, U1.2 (+Vs)
+5V: A1.5 (+5V), BZ1.1 (-), J2.2, J5.3, J5.8, J6.4, SW1.3 (K), SW1.4 (A), SW2.3 (K), SW2.4 (A), SW3.3 (K), SW3.4 (A)
BTN_DOWN: A1.22 (D7), R5.2, SW1.1, SW1.2
BTN_SELECT: A1.20 (D5), R3.2, SW2.1, SW2.2
BTN_UP: A1.21 (D6), R4.2, SW3.1, SW3.2
BUZZER_ON: A1.24 (D9), R6.1, R10.1
GND: A1.6 (GND), A1.7 (GND), A1.29 (GND), H1.1, H2.1, H3.1, H4.1, J1.2, J1.3, J2.1, J2.5, J2.6, J2.7, J2.8, J5.2, J5.9, J6.1, J6.6, Q1.3 (S), Q2.2 (S), R3.1, R4.1, R5.1, R10.2, TP1.1
GND1: C1.2, H5.1, H6.1, J9.1, J9.6, J10.2, J10.9, TP2.1, U1.5 (V_{SS})
HEATER_ON: Q1.1 (G), R2.1, R9.1
HeaterDrive: J5.1, J5.10, J6.3, Q1.2 (D)
HeaterDrive_IB: D1.1 (K), J9.3, J10.1, J10.10
unnamed: A1.23 (D8), R2.2
unnamed: A1.25 (D10), R9.2
unnamed: BZ1.2 (+), Q2.3 (D)
unnamed: D1.2 (A), J11.2
unnamed: F1.2, J1.1, J1.4
unnamed: Q2.1 (G), R6.2
unnamed: R7.1, U1.4 (/SHUTDOWN)
SCL: A1.14 (SCL/A5), J2.3
SDA: A1.13 (SDA/A4), J2.4
TEMP_IN: A1.9 (A0), R1.1
TempOut: J5.4, J5.7, J6.5, R1.2
TempOut_IB: J9.5, J10.4, J10.7, U1.1 (Vout)
VCC: A1.8 (VIN), F1.1, J5.5, J5.6, J6.2
VCCQ: J9.2, J10.5, J10.6, J11.1

File moonratII/hardware_moonratII/pcb_controller_moonratII/Moonrat_BOM_HardwareX.tsv:

Reference	Value	Qty	DNP	Cost	Description
A1	Arduino_UNO_R3 with uUSB and Cable	1		5.65	Arduino UNO EXCEPT with micro USB
BZ1	Buzzer_D12mm_H9.6mm_LS7.6mm	1		0.16	
C1	0.1uF	1		0.0021	50V 100nF X7R ±10% 0603 Multilayer Ceramic Capacitors MLCC - SMD/SMT ROHS
Cable_MoldedFemale1	Cable_02x06_Female	1		7.00	807 Square 6-Way Trailer Wiring Harness Connectors,6 pin Square Trailer Wire Extension for LED Brake Tailgate Light Bars,Hitch Light Trailer Wiring Harness Extension Connector (6 Way-Socket)
Cable_MoldedMale1	Cable_02x06_Male	1		7.00	Cable_02x06_Male
Cable_Ribbon1	Cable_02x05	1		6.75	Cable_02x05
D1	Schottky 2A	1		0.0343	
F1	Polyfuse 6A	1		0.0691	16V 3A 40A 6A 1812 Resettable Fuses ROHS
H1,H2,H3,H4,H5,H6	MountingHole_Pad_3.5mm	6		0	MountingHole_Pad_3.5mm
J1	Barrel_Jack_Switch_SMT	1		0.205	Power Barrel Connector Jack 2.10mm ID (0.083"), 5.50mm OD (0.217") Surface Mount, Right Angle
J2	HS96L03W2C03_0.96_Oled	1		1.64	OLED Displays Modules ROHS
J5,J10	Conn_02x05_Odd_Even	2		0.0655	2.54mm Straight 2x5P 5 Push - Pull 2.54mm 2 Plugin,P=2.54mm IDC Connectors ROHS
J6,J9	Screw_Terminal_01x06	2		0.4614	1x6P -40℃~+105℃ 8A 130V Green 18~26 Straight 2.54mm 1 1 6 Plugin,P=2.54mm Screw terminal ROHS
J11	Screw_Terminal_01x02	1		0.1537	1x2P 6A 150V Green 18~26 Straight 2.54mm 1 1 2 Plugin,P=2.54mm Screw terminal ROHS
MF1,MF2,MF3	CAP TACTILE ROUND IVORY 6.00mm Dia	3		0.95	Round Tactile Switch Cap Ivory Slip On, 6.00mm Dia x 5.50mm H
MF4,MF5,MF6,MF8	SMD_round_nut_M2*4*5+1.5	4		0.0736	
MF7,MF9,MF10,MF11	Steel Pan Head Phillips Screw M2 x 0.4 mm Thread, 6 mm Long	4		0.05	
MF12	250V 3A Straight Square Pins 2.5mm 4P 6mm -40℃~+105℃ 3mm 2.54mm Plugin Black 1x4P Plugin,P=2.54mm Pin Headers ROHS	1		0.0201	
Q1	IRF540N	1		0.3480	100V 33A 44mΩ@10V,16A 130W N Channel TO-220 MOSFETs ROHS
Q2	BSS138	1		0.0196	N-Channel Enhancement Mode Field Effect Transistor
R1,R7	1R	2		0.0015	0.1W ±5% 1Ω 0603 Chip Resistor - Surface Mount ROHS
R3,R4,R5,R6,R9	1K	5		0.0015	0.1W ±1% 1kΩ 0603 Chip Resistor - Surface Mount ROHS
R8	Heater	1		4.50	Heating Pad - 5x10cm
R10	10K	1		0.0036	100mW ±1% 10kΩ 0603 Chip Resistor - Surface Mount ROHS
SW1,SW2,SW3	6mm 2 Pin Tact NO Breadboard Friendly	3		0.1091	
U1	TMP36GRTZ-REEL7	1		1.2837

## Code that names these connections

File moonrat/moonrat.ino (part):

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
//pin variables
#define HEAT_PIN 8
#define BTN_UP 6
#define BTN_DOWN 7
#define BTN_SELECT 5
#define BZR_PIN 9

//temperature variables
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  // put your setup code here, to run once:
  Serial.begin(9600); //Start the Serial Port at 9600 baud (default)

  pinMode(BTN_UP, INPUT);
  pinMode(BTN_DOWN, INPUT);
  pinMode(BTN_SELECT, INPUT);
  pinMode(BZR_PIN, OUTPUT);
  digitalWrite(BZR_PIN, LOW);
  pinMode(HEAT_PIN, OUTPUT);
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
## Commit log (part)

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2023-07-30 Create README.md
    Add Live view links for KiCad files and screen shots for schematic, PCB and 3D PCB.
2023-07-30 Update README.md
    Put the kicanvas links into a table.
2023-07-31 Add switch and key cap files.
2023-08-16 Add OLED display files.
2023-09-01 Sort BOM by distributor.
2023-09-21 Created a footprint fuse BSMD1812
2023-10-15 Add a FreeCAD file for an enclosure top.
2023-10-15 Create README.md
    Add a read me for the enclosure
2023-10-15 Refine the enclousre top and in assembly.
2023-10-15 New OLED footprints
2023-10-15 Deleted unwanted project
2023-10-16 Fixed OLED footprint, BOM maintenance
2023-11-02 moonratII
2023-11-04 Deleted board to board headers. Placed components before getting to route
2023-11-04 Routed the PCB main side
2023-11-06 Performing design rule checks. Added ground between SCL & SDA traces to reduce the opportunity for cross talk.
2023-11-06 Update README.md
    Fix an terrible spelling mistake.
2023-11-06 PCB: Solved 2 DNR errors and added teardrops.
2023-11-06 Solved 2 more PCB DNR errors.
2023-11-09 Cleared all DRC errors and warnings. Added 3 footprints
2023-11-12 Issue 53: Added key caps to switches in schematic
2023-11-15 Trouble shooting issues with JCLPCB order.
2023-11-19 Fix 3D models buzzer. Some tweeks to enclosure top but still not up to date.
2023-11-19 Update PCB with footrpint with OLED display 3D model.
2023-11-20 Add footrpint for OLED using the SMD round nuts to be soldered into PCB.
2023-11-20 Updated the footprint to the OLED
2023-11-21 Added Gerber files
2023-11-24 Add step model(s) to tac switch
2023-11-30 Updated all related files and ordered PCB and Assemblies through JLCPBC.
2023-12-02 Changed connector part number due to availability
2023-12-02 Deleted .DS_Store files
2023-12-04 Update README.md
    Update the enclosure top and assembly drawing.
2023-12-04 UPdate enclosure top and assembly drawing. Generate a new PWA step.
2023-12-04 Update README.md
    Update with 10 mm key cap.
2023-12-06 Added the buzzer dimensions to mechanical drawing issue 141
2023-12-17 Create Add file
2023-12-17 Add README.md file
2023-12-17 Significant folder rearrangement
2023-12-25 Fix error on PCB mount, delete a circle. Fix offset on switch and buzzer.
2023-12-26 Update enclousre assembly with a screw.
2023-12-28 Update README.md
    Outline requirements for firmware to test the MoonRat II.
2023-12-31 Create manufacturing_test
2023-12-31 Update README.md
    Fix broken KiCanvas links.
    No idea why they were broken or when.
2023-12-31 Rename Manufacturing_Test_MoonRatII_V1.md to README.md
2024-01-22 Revert "Add files via upload"
2024-01-27 Update README.md
    Notes during assembly of 20240126.
2024-02-06 Create Arduino test
    Folder created for Arduino test codes
2024-02-07 Increase size on Heater traces.
2024-02-07 Clean up some via spacing and ground pours.
2024-02-11 Copying Horacios Wokwi 20240211
2024-02-14 adding initial commit of Horacios code
2024-02-14 Update README.md
    Fix CR and LF
2024-02-15 Update README.md
    Update description of the Can21Oz and experiments for heating and cooling.
2024-02-21 changing button polarity
2024-02-28 update heater pin out and buzzer pin output
2024-02-28 Add switch drawing, Omron. Add Photos of Rev1 assemblies from testing.
2024-03-02 Fix issues 210, 211, 215, 195, and 216.
2024-03-02 Change date of schematic and PCB for rev 2. Tweek to PCB after changing BoardSetupContratins.
2024-03-02 Change Q1 to IRF540NPBF for higher current rating.
2024-03-03 Add resistor so buzzer off during reset.
2024-03-03 Add position file. Change UNO description to mUSB and with cable.
2024-03-03 Add the manufacturing placement files, JLCPCB.
2024-03-26 Update README.md
    Delete stale information from OEDCS manufacturing test from which this was copy paste.
    Add reference to Issue #209 for rework around USB to SW1 short.
2024-04-24 Update README.md
    Capture in the README.md of the legacy folder the project of status before 2023.
2024-04-24 Rob uses "Robert L. Read" as his professional name.
2024-05-15 Create Folder PIDmoonTestControl
2024-05-15 README.md
2024-05-15 Update README.md
    Add some images for the heater assembly enclosure readme.
2024-05-23 Add a parameterized FreeCad file for Petrifilms
2024-05-28 making the perforation work a little better
2024-06-10 Sensor proofs code
    An Arduino code to test the sensor is added. Here we can test and get the voltages and sensor's temperature measured. In the cases with an R3 and a R4.
2024-06-17 Add an enclosure for the MoonRatII Controler top.
2024-07-05 Add files via upload
    Top and basis v2 of monrat enclousure II
2024-07-19 moving back
2024-07-30 Update LICENSE
2024-08-10 MoonRatRob6 proves that an R3 can't run our Fuzzy code
2024-08-12 partial reorgnization of code, and taking some of the R4 code into this
2024-08-12 some improvements, porting latest R4 code into R3 code, working
2024-09-18 Add an assembly file with the enclosure of August 2024. Add screen shot to reead me too.
2024-09-22 Create PCB User Guide - Order from JLCPCB
2024-09-22 Update How to Order from JLCPCB
2024-09-24 cables connection
    Cables connection to principal pcb and heater pcb
2024-09-24 PID and Fuzzy updated
2024-09-25 Rename 328705935-1730ba22-5495-4049-9fdf-aee25eee9fa9.jpeg to cable_connection2.jpeg
2024-10-11 Create map_gen.py
    The Python script generates and plots the system's heat map.
2024-10-20 battery-time images
2024-10-21 last image
2024-10-28 Rename MoonratII_version2_BOMxls.xls to MoonratII_ver2_BOM.xls
2024-11-02 separating time persistence, display not working
2024-11-06 Create Feature issue template
2024-11-06 Created a hardware issue template
2024-11-06 Update issue templates
2024-12-05 Updating previous changes.
2024-12-06 Modified BOM, schematic, and created assembly in Freecad of PWA and enclosure.
2024-12-06 Update README.md: Added 20141205 Freecad assembly file designs and a markdown table.
2024-12-06 Update .gitignore Added .lck files
2024-12-06 Created assembly file
2024-12-07 Deleted controller from heater board Schematic and PCB files. Deleted proxy from Assy_Enclosure_Rev2_PWA.FCStd file.
2024-12-08 some progress on this
2024-12-08 updating code
2024-12-09 further improvements
2025-01-09 PID seems to be working now.
2025-01-13 major updates
2025-01-14 finally have the buttons working
2025-01-14 Added a 4.7 pull up resistor to heater board.
2025-01-14 Added datasheet and step file.
2025-01-14 Updated PCB.
2025-01-15 cleaing up and reorganizing code
2025-01-15 additional improvements
2025-03-16 Created Moonrat Rev 2.1 folder.
2025-04-12 Updated heater schematic
2025-04-21 Deleting Kicad version 8 files.
2025-04-21 Deleting unneeded pcb_heater folder.
2025-04-21 Deleting unneeded moonratII_2_1 folder containing pcb_heater folder.
2025-04-28 heaterboard_1.kicad_sch Replacing TMP36 with TSIC206-TO92.
2025-04-28 README.md fixed spelling error.
2025-04-29 heaterboard_1/heaterboard_1.kicad_sch Adding Dallas One symbol and datasheet to schematic.
2025-04-29 heaterboard_1/heaterboard_1.kicad_sch Adding DS18B20 digital thermometer and 4.7 resistor to schematic, add datasheet.
2025-04-29 heaterboard_1.kicad_sch Using bulk editor, all part numbers and vaules correct.
2025-05-02 heaterboard_1/heaterboard_1.kicad_sch Addingnet names and added external components boundary box.
2025-05-02 heaterboard_1/heaterboard_1.kicad_sch Hiding GND fill and locked components.
2025-05-05 heaterboard_1/heaterboard_1.kicad_pcb Removed deleted components from the PCB.
2025-05-05 heaterboard_1/heaterboard_1.kicad_pcb Adding new test points and parts from schematic to the PCB.
2025-05-06 heaterboard_1/heaterboard_1.kicad_pcb Setting the Heater Board edge cut.
2025-05-16 heaterboard_1.kicad_pcb Added open source symbol to the PCB silkscreen layer and unified title block for board silkscreen and schematic.
2025-05-20 heaterboard_1.kicad_pcb and _sch files Cleared all design errors and warnings.
2025-05-20 Adding PCB connector step files.
2025-05-26 heaterboard_1.kicad_sch, change H5 and H6 to exclude from BOM. Generate CSV BOM file. Modify .gitignore so as to put CSV under version control.
2025-05-27 case_incubater.FCStd, Renamed: added descriptive names to features.
2025-05-27 case_incubater.FCStd, Added Platform Mount with mounting holes.
2025-05-27 case_incubater.FCStd, Exported STEP file.
2025-06-10 cover.FCStd: Recomputed for v1 Freecad.
2025-08-06 pcb_moonratII.kicad_pcb, repaired switch STEP file.
2025-08-06 pcb_moonratII.step, updated 3D models for keycaps and buzzer.
2025-08-07 cover.FCStd Renamed body terms.
2025-08-08 cover.FCStd, added descriptive feature names.
2025-08-08 cover.FCStd, cleared Wire Not Closed error on OLED and mounting hole centered.
2025-08-11 Changed spreadsheet.
2025-08-20 cover.FCStd, created a formula correctly locate SW1, Sw2, SW3, and buzzer to new MH2 origin.
2025-08-20 cover.FCStd, fully contrained switches, OLED, and buzzer.
2025-08-21 cover.FCStd, remove the feature Pocket_OLED_Buzzer_Keycaps, because we are now defining that geometry in the same sketch as the mounting holes (Pocket_PWA, MountingHoles).
2025-08-21 cover.FCStd, confirmed that the PWA is properly positioned and parameterized the cover body height and width.
2025-08-27 cover.FCStd, positioned SW2 and SW3 correctly.
2025-08-27 cover.FCStd, added allowance for buzzer diameter.
2025-08-27 cover.FCStd, changed view for cross-section.
2025-08-28 cover.FCStd, changed the map mode Sketch003, attached it to Body.Pad.Face06, and changed the Pad_Body height.
2025-08-28 cover.FCStd, parameterized CoverCavityLength to move cover above OLED display.
2025-08-28 cover.FCStd, MountingHoles pad through all.
2025-08-29 moonratII/, corrected folder name from enclosure_mooonratII to enclosure_moonratII.
2025-08-29 moonratII/, updating file structure, files, and folders.
2025-08-29 moonratII, organizing folders and files.
2025-08-29 chore: remove obsolete BOM file and its now-empty directory
2025-08-29 Rename moonratII/hardware_moonratII/pcb_controller_moonratII/GeneralPurposeAlarmDevicePCB.pretty/moonratII/hardware_moonratII/pcb_controller_moonratII/GeneralPurposeAlarmDevicePCB.pretty/ScrewTermina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
2025-08-29 Rename moonratII/hardware_moonratII/pcb_controller_moonratII/GeneralPurposeAlarmDevicePCB.pretty/moonratII/hardware_moonratII/pcb_controller_moonratII/Terminal_5.08mm_1x2 to moonratII/hardware_moonra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
2025-08-29 Rename 1x2P 20A -40℃~+105℃ 300V Green 12~30 Straight pin 5.08mm 2.5 1 2 Plugin,P=5.08mm Screw terminal ROHS.kicad_mod to ScrewTerminal_5.08mm_1x2.kicad_mod
2025-08-31 fixing some bugs found when writing paper.
2025-09-05 now can set incubation time
2025-09-05 adding missing files
2025-09-05 allowing persistence of incubation time
2025-09-08 base_Rev2_Freecad1.0.FCStd, Add mounting holes to bosses. Dimensioned from cover file.
2025-09-10 cover.FCStd, Narrow clearance around J5, J6.
2025-09-10 cover.FCStd, Eye ball clearance for Stackable Sockets.
2025-09-10 cover.FCStd, Eye ball lock platform dimensions.
2025-09-11 cover.FCStd, develoope Boss higher. Tweek counterbore for screws.
2025-09-11 Add PhillipsRoundedHeadThreadFormingScrews drawing.
2025-11-17 cover_v2_20251116-Body_Cover, enlarged and left shifted switch holes, as well as widened power jack opening.
2025-11-30 Created folder in main containing Silvia's files.
2025-12-01 Project closeout preperation: marked files and folders for later deletion.
2025-12-01 Deleted redundant or obsolete files.
2025-12-11 hardware_moonratII/ Creating new BOM and Gerber file for controller and heaterboard.
2025-12-15 removing obsolete directories
2025-12-15 removing old file
2025-12-26 hardware_moonratII/, create pcb_controller_moonratII and pcb_heaterboard_1_moonratII gerber folders and files.
2026-04-27 adding heat data
2026-05-26 tweak default temp. to 35
2026-06-01 some improvement
2026-06-01 calibration system
2026-06-03 Rename HARDWAREX-MoonRatII.odt to OBSOLETE-HARDWAREX-MoonRatII.odt

Notices in the files:
heaterboard_1/heaterboard_1.kicad_pcb:
GNU Affero General Public License v3.0
moonratII/pcb_moonratII/moonratII.kicad_pcb:
CERN Open Hardware License Version 2 - Strongly Reciprocal
