File: moonratII/moonratII/moonratII.kicad_pcb (KiCad board)
At the start: 2 copper layers, 108 x 65 mm, 34 parts, among them J1 Barrel_Jack_Switch_SMT, J10 Conn_02x05_Odd_Even, J11 Screw_Terminal_01x02, J2 HS96L03W2C03_0.96_Oled, J5 Conn_02x05_Odd_Even, J6 Screw_Terminal_01x06, J9 Screw_Terminal_01x06, Q1 IRF520N, Q2 BSS138, SW1 6mm 2 Pin Tact NO Breadboard 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

Commit message: PCB: Solved 2 DNR errors and added teardrops.
Routing:
- net SDA: vias 6 -> 7

Commit message: Solved 2 more PCB DNR errors.
Routing:
- net HeaterDrive: track 52.6 -> 54.3 mm
- net VCC: track 168.2 -> 168.9 mm
- net SCL: track 62.1 -> 62.4 mm, vias 3 -> 4
